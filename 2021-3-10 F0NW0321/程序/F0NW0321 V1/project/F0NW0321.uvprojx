# Keil uVision project F0NW0321.uvprojx, settings and files
target F0NW0321 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F0NW0321_V1_0320 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\src;..\HEAD;..\USER\APP;..\USER\FCT;..\USER\HEAD;..\USER\HARDWARE;..\USER\PROTOCOL;..\USER\USMART;..\EACT;..\USER\ICT;..\USER\Upload;..\USER\Sensor;..\USER\PYD1698;..\USER\RF
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group USMART
    ../USER/USMART/: usmart.c usmart_config.c usmart_str.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group HARDWARE
    ../USER/HARDWARE/: ADC.c DAC.c global.c Timer.c 24cxx.c Sup_Fun.c ad7176.c Analog_Switch.c LCD3033.c AD5933.c Fre.c
  group PROTOCOL
    ../USER/PROTOCOL/: myiic.c NET_iic.c usart.c usart1.c usart2.c usart3.c uart4.c uart5.c
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group APP
    ../USER/APP/: other.c menu.c Barcode.c debug.c Hold_data.c List_test.c Test_Config.c ETH_Config.c Base_Config.c Block_Check.c reg_config.c Sample_Notice.c Dot.c motor.c usb_move.c
  group EACT
    ../EACT/: modbus.c CRC.c X_axis.c XY_axis.c Y_axis.c
  group ICT
    ../USER/ICT/: open.c os.c mR.c KOhm.c short.c diode.c uF.c pF.c os_study.c
  group FCT
    ../USER/FCT/: Hall.c LDO.c Leakage_I.c led.c Switch.c MIC.c ID.c
  group RF
    ../USER/RF/: SuBUS.c RF.c RF_ID.c
  group Upload
    ../USER/Upload/: JDT.c WTB.c ZDT.c data.c cmd.c
  group Doc
    ../Doc/: readme.txt
